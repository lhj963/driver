# Keil uVision project st_driver.uvproj, settings and files
target st_driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: st_driver +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Source\main;..\Source\device;..\Source\drivers
  library: MicroLIB
  scatter file: .\output\st_driver.sct
  group device
    ../Source/device/: startup_stm32f10x_hd.s core_cm3.c
  group hal
    ../Source/hal/: hal.c
  group main
    ../Source/main/: main.c
  group apps
    ../Source/apps/: apps.c
  group drivers
    ../Source/drivers/: drivers.c cortex_m3.s
  group os
    ../Source/os/: cpu_c.c os.c cpu_s.s
